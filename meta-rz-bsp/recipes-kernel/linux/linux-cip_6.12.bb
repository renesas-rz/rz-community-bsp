DESCRIPTION = "CIP SLTS Linux kernel v6.12"

require linux.inc

KERNEL_URL = "git://gitlab.com/cip-project/cip-kernel/linux-cip.git"
KBRANCH = "linux-6.12.y-cip"
SRCREV = "f0ff96b9db4c6dd62a05fb58babf7d08c83909de"

LINUX_VERSION = "6.12.114-cip34"
