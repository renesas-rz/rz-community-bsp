# Copyright (c) 2024, Renesas Electronics Corp.
#
# SPDX-License-Identifier: MIT

RDEPENDS:${PN} += " \
	startup \
"