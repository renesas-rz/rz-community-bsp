# Copyright (c) 2024, Renesas Electronics Corp.
#
# SPDX-License-Identifier: MIT

CORE_IMAGE_BASE_INSTALL += " \
	startup \
"
